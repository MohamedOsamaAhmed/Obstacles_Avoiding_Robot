# Keil uVision project Main.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80C51BH Intel
  cpu: IRAM(0-0x7F)  IROM(0-0xFFF) CLOCK(12000000)
  output: Main +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 Main.c Obstacles_Avoiding_Robot_cfg.h Servo.h Servo.c UltraSonic_Sensor.c UltraSonic_Sensor.h Delays_Functions.c Delays_Functions.h Motors.c Motors.h
